KERNEL_SRC = "git://github.com/Renn22/linux-imx.git;protocol=git"
SRCBRANCH = "EvoX"
SRCREV = "${AUTOREV}"
